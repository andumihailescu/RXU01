## sdkconfig.defaults
```kconfig
# ESP32-C3 RXU01 hardware defaults.
CONFIG_ESPTOOLPY_FLASHSIZE_2MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="2MB"
```
